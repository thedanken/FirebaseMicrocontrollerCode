# Keil uVision project RFID_STM32Lib.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RFID_STM32Lib
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: tm_stm32f4_spi.h tm_stm32f4_mfrc522.h defines.h tm_stm32f4_mfrc522.c tm_stm32f4_spi.c rfidEx.c tm_stm32f4_gpio.h tm_stm32f4_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_spi.h attributes.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:Startup 2.6.3
